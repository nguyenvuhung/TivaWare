# Keil uVision project qs-rgb.uvprojx, settings and files
target qs-rgb (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: qs-rgb
  AfterMake: fromelf --bin --output .\rvmdk\qs-rgb.bin .\rvmdk\qs-rgb.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1 UART_BUFFERED
  c misc: --c99
  c include: ..;..\..\..\;..\..\..\third_party\lwip-1.4.1\src\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: qs-rgb.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: buttons.c rgb.c
    ./: qs-rgb.c rgb_commands.c startup_rvmdk.S
    ../../../utils/: cmdline.c uartstdio.c ustdlib.c
  group Libraries
    ../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
software components: CMSIS:CORE 5.0.0
